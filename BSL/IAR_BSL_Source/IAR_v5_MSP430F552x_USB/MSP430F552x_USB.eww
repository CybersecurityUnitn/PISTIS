<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP430F552x_USB.ewp</path>
  </project>
  <batchBuild/>
</workspace>


