# IAR project MSP430F552x_USB.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 400
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; ../Peripheral_Interfaces/USB/; ../Command_Interpreter/; ../API/; ../Peripheral_Interfaces/
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.IccLang: 0
  XLINK.XclFile: CONFIG\lnk430_BSL_AREA_RAM_2400-33FF.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 160
  General.GHeapSize2: 160
  ICC430.newCCIncludePaths: $PROJ_DIR$; ..\API; ..\Command_Interpreter; ..\Peripheral_Interfaces
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  group (top)
    ../API/: BSL430_API.c
    ../Command_Interpreter/: BSL430_Command_Interpreter.c
    ./: BSL430_Low_Level_Init.s43
    ../Peripheral_Interfaces/USB/: BSL430_USB_PI.c
  group Header
    ../API/: BSL430_API.h
    ../Command_Interpreter/: BSL430_Command_Definitions.h BSL430_Command_Interpreter.h
    ../Peripheral_Interfaces/: BSL430_PI.h
    ./: BSL_Device_File.h
    ../Peripheral_Interfaces/USB/: defUSB.h descriptor.h descriptors.h device.h hal_UCS.h Proj_Settings.h types.h usb.h usbapi.h UsbHidReq.h UsbIsr.h
  group Source
    ../Peripheral_Interfaces/USB/: cstartup.s43 descriptors.c hal_UCS.c usb.c UsbApi.c UsbHidReq.c UsbIsr.c
